# Keil uVision project Dragon.uvproj, settings and files
target Dragon (ARM-ADS)
  device: NUC442JI8AE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: Dragon
  c flags: Optim=3 OneElfS=1
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\NUC472_442\Include;..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_NUC472_442.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    ../Library/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group Library
    ../Library/StdDriver/src/: clk.c gpio.c i2s.c retarget.c sys.c uart.c
  group User
    ../User/: main.c nuc472_442_isr.c process.c
